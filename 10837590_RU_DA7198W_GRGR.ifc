Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-07-07T06:50:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 07 06:50:10 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{B10A955E-4F21-4D11-A861-D9082A4D2B1E}\ifc * Database version: 5507 * Database creation date: Wed Jul 07 06:50:09 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 07 06:50:09 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 07 06:50:09 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 28719860_RU_10837590_DA7198W_GRGR, 10837590_RU_DA7198W_GRGR:28719860_RU_10837590_DA7198W_GRGR:209452
In: Level 1
Type - Material: z_Miele_Design_GRGR, z_Miele_Connection_ExhaustAir, z_Miele_Connection_Electric, Aluminum, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass, z_Miele_Design_CLST
Pset_BuildingElementProxyCommon - Reference: 28719860_RU_10837590_DA7198W_GRGR
Pset_ManufacturerTypeInformation - Manufacturer: Miele
